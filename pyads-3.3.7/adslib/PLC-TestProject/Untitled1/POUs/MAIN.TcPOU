PROGRAM MAIN
VAR
	byByte		AT %MB0 : ARRAY [0..1027] OF BYTE;
	i			: INT;
	moreBytes	: ARRAY [0..8192] OF BYTE;
END_VAR

FOR i := 4 TO 1027 BY 1 DO
	byByte[i] := byByte[i] + 1;
END_FOR

END_PROGRAM
